# IAR project Prj_Murata_L462.ewp, settings and files
configuration Prj_Murata_L462 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L462RE ST STM32L462RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; DISCO_L462; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_CUSTOM_CONFIG=0
  ICCARM.CCIncludePath2: ..\..\Core\Inc; ..\..\STM32_Cellular\App; ..\..\STM32_Cellular\Target; ..\..\..\..\..\..\Drivers\BSP\B_L462E_CELL01; ..\..\..\..\..\..\Drivers\BSP\Components\ssd1315; ..\..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\..\Middlewares\Third_Party\LiamBindle_mqtt-c\include; ..\..\..\..\..\..\Middlewares\Third_Party\MbedTLS\include; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Com\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Custom\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Echo\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\HTTP\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\MQTT\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Ping\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\UI\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Mngt\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Data_Cache\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Cmd\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\DataCache_Supplier\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\MbedTLS_Wrapper\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Ndlc\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Ndlc\Interface\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Setup\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\SPI\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Stack_Analysis\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Time_Date\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Network_Library\Includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Core\Inc; ..\..\STM32_Cellular\App
  OBJCOPY.OOCOutputFile: Prj_Murata_L462.bin
  ILINK.IlinkOutputFile: Prj_Murata_L462.out
  ILINK.IlinkIcfFile: stm32l462xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Prj_Murata_L462_LwIP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; USE_SOCKETS_TYPE=USE_SOCKETS_LWIP; DISCO_L462; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_CUSTOM_CONFIG=0
  ICCARM.CCIncludePath2: ..\..\Core\Inc; ..\..\STM32_Cellular\App; ..\..\STM32_Cellular\Target; ..\..\..\..\..\..\Drivers\BSP\B_L462E_CELL01; ..\..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\..\Middlewares\Third_Party\LiamBindle_mqtt-c\include; ..\..\..\..\..\..\Middlewares\Third_Party\MbedTLS\include; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Com\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Custom\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Echo\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\HTTP\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\MQTT\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\Ping\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Samples\UI\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Mngt\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Data_Cache\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Cmd\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\DataCache_Supplier\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\MbedTLS_Wrapper\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Ndlc\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Ndlc\Interface\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Setup\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\SPI\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Stack_Analysis\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Modules\Time_Date\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Network_Library\Includes; ..\..\..\..\..\..\Drivers\BSP\Components\ssd1315
  ICCARM.CCOptLevel: 0
configuration Prj_Murata_L462_Rel (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; SW_DEBUG_VERSION=0; DISCO_L462; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_CUSTOM_CONFIG=0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
configuration Prj_Murata_L462_LwIP_Rel (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; USE_SOCKETS_TYPE=USE_SOCKETS_LWIP; SW_DEBUG_VERSION=0; DISCO_L462; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_CUSTOM_CONFIG=0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
configuration Jenkins_Config (ARM, debug)
  as the first configuration, except:
configuration Jenkins_CodeSonar (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; DISCO_L462; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_CUSTOM_CONFIG=0; SW_DEBUG_VERSION=0
  group Application/EWARM
    ./: startup_stm32l462xx.s
  group Application/User
    ../../Core/Src/: adc.c gpio.c i2c.c main.c quadspi.c rng.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c tim.c usart.c usb.c
  group Drivers/BSP/B_L462_CELL01
    ../../../../../../Drivers/BSP/B_L462E_CELL01/: stm32l462e_cell01.c stm32l462e_cell01_hsensor.c stm32l462e_cell01_lcd.c stm32l462e_cell01_psensor.c stm32l462e_cell01_tsensor.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC
    ../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Src/: at_custom_modem_api.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c sysctrl_specific.c
    ../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Inc/: plf_modem_config.h
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/Cellular/Core/AT_Core
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_signalling.c at_modem_socket.c at_parser.c at_util.c sysctrl.c
  group Middlewares/Cellular/Core/Cellular_Service
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_task.c cellular_service_utils.c
  group Middlewares/Cellular/Core/Error
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/Cellular/Core/HW_Specific
    ../../STM32_Cellular/Target/: board_buttons.c board_display.c board_interrupts.c board_leds.c
  group Middlewares/Cellular/Core/Ipc
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/Cellular/Core/PPPosif
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Src/: ppposif.c ppposif_client.c ppposif_ipc.c
  group Middlewares/Cellular/Core/Rtosal
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/Cellular/Core/Runtime_Library
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/Cellular/Core/Trace
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/Cellular/Interface/Cellular_Mngt
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Mngt/Src/: cellular_mngt.c
  group Middlewares/Cellular/Interface/Com
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c com_utils.c
  group Middlewares/Cellular/Interface/Data_Cache
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Data_Cache/Src/: dc_common.c
  group Middlewares/Cellular/Modules/Cmd
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/Cmd/Src/: cmd.c
  group Middlewares/Cellular/Modules/DataCache_Supplier
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/DataCache_Supplier/Src/: dc_generic.c dc_mems.c
  group Middlewares/Cellular/Modules/MbedTLS_Wrapper
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/MbedTLS_Wrapper/Src/: mbedtls_credentials.c mbedtls_entropy.c mbedtls_timedate.c
  group Middlewares/Cellular/Modules/Ndlc
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/Ndlc/Core/Src/: ndlc.c ndlc_commands.c
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/Ndlc/Interface/Src/: spi_ndlc.c
  group Middlewares/Cellular/Modules/Setup
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/Setup/Src/: app_select.c feeprom_utils.c menu_utils.c setup.c voucher.c
  group Middlewares/Cellular/Modules/SPI
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/SPI/Src/: sys_spi.c
  group Middlewares/Cellular/Modules/Stack_Analysis
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/Stack_Analysis/Src/: stack_analysis.c
  group Middlewares/Cellular/Modules/Time_Date
    ../../../../../../Middlewares/ST/STM32_Cellular/Modules/Time_Date/Src/: time_date.c
  group Middlewares/Cellular/Samples/Com
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/Com/Src/: comclient.c
  group Middlewares/Cellular/Samples/Custom
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/Custom/Src/: custom_client.c
  group Middlewares/Cellular/Samples/Echo
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/Echo/Src/: echoclient.c
  group Middlewares/Cellular/Samples/Freertos
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/Freertos/Src/: freertos.c
  group Middlewares/Cellular/Samples/HTTP
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/HTTP/Src/: httpclient.c
  group Middlewares/Cellular/Samples/MQTT
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/MQTT/Src/: mqttclient.c
  group Middlewares/Cellular/Samples/Ping
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/Ping/Src/: ping_client.c
  group Middlewares/Cellular/Samples/UI
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/UI/Src/: uiclient.c
  group Middlewares/Network_Library/core
    ../../../../../../Middlewares/ST/STM32_Network_Library/core/: net_address.c net_class_extension.c net_core.c net_os.c net_socket.c net_state.c
  group Middlewares/Network_Library/netif
    ../../../../../../Middlewares/ST/STM32_Network_Library/netif/cellular_if/: net_cellular.c
  group Middlewares/Network_Library/services
    ../../../../../../Middlewares/ST/STM32_Network_Library/services/: net_mbedtls.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/LiamBindle_mqtt-c
    ../../../../../../Middlewares/Third_Party/LiamBindle_mqtt-c/src/: mqtt.c mqtt_pal.c
  group Middlewares/Third_Party/LwIP/api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LwIP/core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LwIP/core/ipv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LwIP/netif/ppp
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
  group Middlewares/Third_Party/LwIP/system/OS
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/MbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group plf_config
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Inc/: cellular_service_config.h
    ../../STM32_Cellular/App/: cmsis_os_misrac2012.h FreeRTOSConfig.h lwipopts.h plf_cellular_config.h plf_config.h plf_features.h plf_hw_config.h plf_ipc_config.h plf_power_config.h plf_sw_config.h plf_thread_config.h
    ../../../../../../Middlewares/ST/STM32_Cellular/Samples/Custom/Inc/: plf_custom_config.h
