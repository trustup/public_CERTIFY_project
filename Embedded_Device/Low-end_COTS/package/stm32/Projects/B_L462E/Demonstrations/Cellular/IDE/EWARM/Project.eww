<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Prj_Murata_L462.ewp</path>
  </project>
  <batchBuild />
</workspace>
